# IAR project Project.ewp, settings and files
configuration STM32F303K8_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303K8 ST STM32F303K8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303x8; USE_STM32F3XX_NUCLEO_32; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F3xx_Nucleo_32; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32F303K8-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f303x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f303x8.s
  group Application/User
    ../Src/: main.c stm32f3xx_hal_timebase_tim.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F3xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32F3xx_Nucleo_32/: stm32f3xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
